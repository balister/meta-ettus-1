FILESEXTRAPATHS_prepend := "${THISDIR}/files/${MACHINE}:"

dirs755 += " /media/FAT"

PACKAGE_ARCH = "${MACHINE_ARCH}"
